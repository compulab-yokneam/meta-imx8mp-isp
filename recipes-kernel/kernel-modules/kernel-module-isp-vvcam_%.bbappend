FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-ov5647-sensor-enablement-for-linux-version-6.1.55-an.patch"
SRC_URI += "file://0002-imx219-sensor-enablement-for-linux-version-6.1.55-an.patch"
